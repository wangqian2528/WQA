# IAR project flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Frame; ..\User; ..\HAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: flashloader.srec
  ILINK.IlinkOutputFile: STM32H750_QSPI.out
  ILINK.IlinkIcfFile: FlashSTM32H7xx.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group Frame
    ../Frame/: flash_loader.c flash_loader_asm.s
  group User
    ../User/: flash_loader_user.c qspi.c sys.c w25qxx.c
